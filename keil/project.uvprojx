# Keil uVision project project.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSPM0G3507__
  c include: .\Include;..;..\MCU_Drives;..\ti\devices\msp\peripherals
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group APP
    ../APP/: main.c
    ./: startup_mspm0g350x_uvision.s
    ../: untitled.syscfg
  group MCU_Drives
    ../MCU_Drives/: ti_msp_dl_config.c ti_msp_dl_config.h atk_md0430_font.h lcd.h lcd.c i8080ctrl.c i8080ctrl.h lcd_touch.c lcd_touch.h lcd_touch_iic.c lcd_touch_iic.h demo.c demo.h lcd_touch_ftxx.c lcd_function.c lcd_function.h
  group Driverlib
    ../: driverlib.a
